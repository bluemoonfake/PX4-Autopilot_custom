## src/modules/antenna_tracker/Kconfig
```kconfig
menuconfig MODULES_ANTENNA_TRACKER
	bool "antenna_tracker"
	default n
	---help---
		Enable support for antenna_tracker module
```
